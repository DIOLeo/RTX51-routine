# Keil uVision project 20171212_rtx51ds1302.uvproj, settings and files
target rtx51ds1302 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: rtx51ds1302 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\SYSTEM;..\HARDWARE\ds1302;..\HARDWARE\lcd1602
  link misc: REMOVEUNUSED
  group USER
    ./: task.c
  group HARDWARE
    ../HARDWARE/ds1302/: ds1302.c
    ../HARDWARE/lcd1602/: lcd1602.c
  group SYSTEM
    ../SYSTEM/: delay.c Conf_tny.A51
  group README
    ../README/: README.txt
