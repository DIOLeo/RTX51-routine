# Keil uVision project test.uvproj, settings and files
target 20171209_rtx51LED (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: rtx51_led +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\SYSTEM
  group USER
    ./: task.c
  group SYSTEM
    ../SYSTEM/: Conf_tny.A51
  group README
    ../README/: README.txt
